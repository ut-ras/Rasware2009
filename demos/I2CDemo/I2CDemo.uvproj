# Keil uVision project I2CDemo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RobzDemo
  c flags: Optim=1
  c include: ..\StellarisWare;..\RASLib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group External
    ../StellarisWare/driverlib/rvmdk/: driverlib.lib
    ../StellarisWare/utils/: uartstdio.c
    ../RASLib/Debug/: RASLib.lib
  group Main
    ./: Startup.s I2CDemo.c
