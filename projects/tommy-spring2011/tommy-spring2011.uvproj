# Keil uVision project tommy-spring2011.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: tommy-spring2011
  c flags: Optim=1
  c include: C:\working_dir\Robotathon2010\StellarisWare;C:\working_dir\Robotathon2010\RASLib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: UARTDemo.c MotorDemo.c ServoDemo.c LineSensorDemo.c IRSensorDemo.c EncoderDemo.c MoveStraight.c OhmiesLib.c
  group External
    C:/working_dir/Robotathon2010/RASLib/Debug/: raslib.lib
    C:/working_dir/Robotathon2010/StellarisWare/driverlib/rvmdk/: driverlib.lib
    C:/working_dir/Robotathon2010/StellarisWare/utils/: uartstdio.c
  group Main
    ./: Startup.s tommy-spring2011.c tommy-spring2011.h
